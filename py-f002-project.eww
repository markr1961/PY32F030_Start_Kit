<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\py-f002-project.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>py-f002-project</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
